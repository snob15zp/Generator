# Keil uVision project Generator070-release.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: gen-g070-release +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RELEASE
  c include: ..\User\inc;..\ugfx_2.9\src\gdisp;..\ugfx_2.9\src;..\ugfx_2.9;..\ugfx_2.9\src\gos;..\ugfx_2.9\src\gwin;..\ugfx_2.9\drivers\gdisp\ILI9341;..\ugfx_2.9\src\ginput;..\ugfx_2.9\drivers\ginput\toggle\Pal;..\Display;..\ugfx_2.9\drivers\ginput\touch\FT6x06;..\DriversCommon;..\PowerModes;..\W25QXX;..\Communications;..\Player;..\acc;..\PowerModes
  asm define: RELEASE
  memory RVCT4: ROM 0x8001800 size 0x1d800
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: .\gen_47-release.sct
  group Main
    ../User/src/: main.c BoardSetup.c
  group ugfx
    ../ugfx_2.9/src/: gfx_mk.c
    ../ugfx_2.9/drivers/gdisp/ILI9341/: gdisp_lld_ILI9341.c
    ../ugfx_2.9/drivers/ginput/touch/FT6x06/: gmouse_lld_FT6x06.c
  group Display
    ../Display/: superloopDisplay.c
  group DriversCommon
    ../DriversCommon/: i2c2.c Spi1.c
  group Communications
    ../Communications/: SuperLoop_Comm.c
  group W25qxx
    ../W25QXX/: w25qxx.c
  group Player
    ../Player/: SuperLoop_Player.c
  group ACC
    ../acc/: battery.c DriverBQ28z610.c DRIVERBQ25703.c DriverTPS65982_6.c i2c_API.c i2c1.c mainFSM.c regBQ25703A.c superloop_ACC.c I2C_COMMON.c
  group PowerModes
    ../PowerModes/: board_PowerModes.c
  group DOC
    ./: GenDoc.txt
    ../DOC/: DOCGEN.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.3.0
